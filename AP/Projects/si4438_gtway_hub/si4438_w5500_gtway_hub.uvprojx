# Keil uVision project si4438_w5500_gtway_hub.uvprojx, settings and files
target si4438_w5500_gtway_hub (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: w5500_gateway_17_5_18 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,MRFI_SI4438
  c include: .\Configuration;.\Configuration\Access_Point;..\Applications;..\Applications\shared_applications;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Components\bsp;..\..\Components\bsp\boards;..\..\Components\bsp\boards\bsp_external;..\..\Components\bsp\mcus;..\..\Components\mrfi;..\..\Components\mrfi\radios;..\..\Components\mrfi\radios\common;..\..\Components\mrfi\radios\family1;..\..\Components\mrfi\smartrf\SI4438;..\..\Libraries\RTT;..\..\Libraries;..\..\Components\nwk;..\..\Components\nwk_applications;..\Applications\extranet_applications;..\Applications\shared_applications;..\Applications\swsn_applications;.\Configuration\Gateway;..\..\Components\nwk_layer;..\..\Components\sx1280-driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x16000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cm3_fwlib
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_bkp.c misc.c stm32f10x_pwr.c
  group jlink_debug
    ../../Libraries/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group bsp
    ../../Components/bsp/: bsp.c bsp_isr.c delay.c stm32_beep.c stm32_it_config.c stm32_usart2_gtway.c stm32_reset.c stm32_flash.c stm32_rtc.c
    ../../Components/bsp/boards/: bsp_leds.c
    ../../Libraries/: stm32f10x_it.c
  group mrfi
    ../../Components/mrfi/: mrfi.c sx1276-LoRa.c
  group peer_applications
    ../Applications/: main_swsn_ap.c
  group Configuration
    ./Configuration/Access_Point/: smpl_config.h
    ./Configuration/: smpl_nwk_config.h radio_config_Sx1280.h
    ./Configuration/Gateway/: gtway_config.h
    ../../Components/bsp/boards/: bsp_config.h
    ../../Components/mrfi/smartrf/SI4438/: radio_config_Si4438.h
    ../../Components/mrfi/: mrfi_config.h
    ../../Components/bsp/: flash_start_addr.h
  group sx1280-dricer-c
    ../../Components/sx1280-driver/: sx1280.c sx1280-hal.c sx1280-para.c
  group nwk
    ../../Components/nwk/: nwk.c nwk_api.c nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../Components/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_joinList.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_security.c
  group nwk_layer
    ../../Components/nwk_layer/: nwk_layer.h nwk_layer.lib
  group shared_applications
    ../Applications/extranet_applications/: 69_frm_proc.c
    ../Applications/shared_applications/: usart_isr.c gtway_frm_proc.c uart_frm_proc.c usart_share_info.c usart2_dma_proc.c firmware_info_proc.c usart1_dma_proc.c
  group swsn_applications
    ../Applications/swsn_applications/: 68_frm_proc.c ap_inner_fun.c bui_pkg_fun.c net_freq_agility.c net_frm_proc.c net_list_proc.c net_para_fun.c net_status_fun.c user_def_fun.c
  group extranet_applications
    ../Applications/extranet_applications/: 67_frm_proc.c 77_frm_proc.c 88_frm_proc.c 80_frm_proc.c
  group tx_rx_buffer
    ../Applications/shared_applications/: ed_rx_buffer_fun.c ed_tx_buffer_fun.c ed_tx_fail_buffer_fun.c ed_tx_rx_buffer.h ed_tx_rx_buffer.lib
